# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0xb0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.s arrow.c title_screen.c level_1.c level_2.c level_3.c level_4.c level_5.c gameover_screen.c zero_score.c one_score.c two_score.c three_score.c four_score.c five_score.c
